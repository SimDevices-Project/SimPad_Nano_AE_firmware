# Keil uVision project CH554.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: SimPad-v2-5-latest +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Public/: Debug.C CH554.H Debug.H
    ./USB/Device/: CompositeKM_UTF8.C
    ./: RGB_LIB.C I2C.C
